# Keil uVision project beacon.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L071CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: beacon +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM32L071xx ,USE_FULL_LL_DRIVER,PLATFORM=SX12xxEiger
  c include: .\Drivers\STM32L0xx_HAL_Driver\Inc;.\Drivers\CMSIS\Device\ST\STM32L0xx\Include;.\usr\inc;.\bsp\SX1278\platform;.\bsp;.\bsp\SX1278\platform\sx12xxEiger;.\bsp\SX1278\radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./usr/: main.c stm32l0xx_it.c
  group Radio
    ./bsp/SX1278/radio/: radio.c sx1276.c sx1276-Fsk.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276-FskMisc.c
    ./bsp/SX1278/platform/sx12xxEiger/: sx12xxEiger.c sx1276-Hal.c
    ./usr/: GPS.c
  group BSP
    ./bsp/SX1278/platform/sx12xxEiger/: spi.c
    ./bsp/: bsp_timer.c bsp_usart.c uartPort.c debug.c
  group Driver
    ./Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
software components: CMSIS:CORE 4.2.0, Device:Startup 1.6.0
